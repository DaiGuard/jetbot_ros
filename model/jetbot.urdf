Commit message: add gazebo launc

File: model/jetbot.urdf (robot description, URDF)
Before this commit: robot robot, 4 links, 3 joints
Links:
- link robot__chassis: mass 0 -> 1.0
- link robot__left_wheel: mass 0 -> 1.0
- link robot__right_wheel: mass 0 -> 1.0
